; PROGRAMA QUE LEE UN TEXTO DE MEMORIA
; Y LO DESPLIEGA EN LA PANATALLA
;PROGRAMA PRINCIPAL
	.ORG	0000H	;CODIGO
	LD SP,27FFH	;INICIA STACX
	LD HL,TEXTO1
	CALL DESP_TEXTO
	CALL LEE_TECLADO
	LD HL,TEXTO2
	CALL DESP_TEXTO
	HALT

	.ORG	2000H ;DATOS
TEXTO1 .DB	"ESCRIBE TU NOMBRE: &"
TEXTO2 .DB	"OK: &"
NOMBRE .DB 	"        "
LCD	.EQU	00H
KEYB	.EQU	01H

;SUBRUTINAS
DESP_TEXTO:
	LD A,(HL)
	CP '&'
	JP Z,FIN
	OUT (LCD),A
	INC HL
	JP DESP_TEXTO
FIN:
	RET
	
LEE_TECLADO:
	LD HL,NOMBRE
	IN A,(KEYB)
	LD (HL),A
	RET 	
	
	.END